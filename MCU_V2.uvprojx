# Keil uVision project MCU_V2.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MCU_V2
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Source\main_task
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserAPP
    ./Source/UserAPP/: main.c
  group Driver
    ./Source/Driver/: GPIO.c WDT.c CT16B0.c CT16B1.c Utility.c CT16B5.c SPI0.c PFPA.c
  group Module
    ./Source/Module/: Buzzer.c KeyScan.c Segment.c sst_flash.c
  group Readme
    ./Source/Readme/: readme.txt
  group main_task
    ./Source/main_task/: main_task.c hand_task.c hand_task.h main_task.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
